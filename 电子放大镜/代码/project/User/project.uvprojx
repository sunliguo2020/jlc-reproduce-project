# Keil uVision project project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F072,USE_STDPERIPH_DRIVER
  c include: ..\Startup;..\Library\inc;..\Library\src;..\User;..\Hardware\led;..\Hardware\light_control;..\Hardware\ntc;..\Hardware\touch;..\System\clock;..\System\pwm;..\System\settings;..\System\timer;..\System\tsc;..\System\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Startup/: startup_stm32f072.s system_stm32f0xx.c
  group Library
    ../Library/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Hardware
    ../Hardware/led/: led.c
    ../Hardware/light_control/: light_control.c
    ../Hardware/ntc/: ntc.c
    ../Hardware/touch/: touch.c
  group System
    ../System/pwm/: pwm.c
    ../System/clock/: clock.c
    ../System/settings/: settings.c
    ../System/timer/: timer.c
    ../System/tsc/: tsc.c
    ../System/usart/: usart.c
  group User
    ./: main.c stm32f0xx_it.c
